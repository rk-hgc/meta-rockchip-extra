FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://alsa.patch \
"

